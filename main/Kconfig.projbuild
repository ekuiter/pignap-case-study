## main/Kconfig.projbuild
```kconfig
menu "PIGNAP"

config REED_SWITCH_NUMBER
    int "Number of reed switches"
	range 1 10
	default 3

endmenu
```
